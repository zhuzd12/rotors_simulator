Commit message: dynamic map demo

File: rotors_planner/model/simple_box.urdf (robot description, URDF)
Before this commit: robot simple_box, 1 links, 0 joints
Links:
- link my_box: mass 1.0 -> 10.0
